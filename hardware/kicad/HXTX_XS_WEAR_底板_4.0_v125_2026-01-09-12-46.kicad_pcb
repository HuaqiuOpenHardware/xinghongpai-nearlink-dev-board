# Repository HuaqiuOpenHardware/xinghongpai-nearlink-dev-board

File README.md:

<h1 align="center">Xinghongpai NearLink Dev Board</h1>

<p align="center"><strong>星鸿派 · WS63V100 / Hi3863 星闪开源开发板</strong></p>

<p align="center">
  <a href="README_EN.md">English</a> |
  <strong>简体中文</strong>
</p>

<p align="center">
  <a href="https://p.eda.cn/d-1328625634846441472">原始项目</a> ·
  <a href="hardware/">硬件设计</a> ·
  <a href="hardware/bom/">BOM</a> ·
  <a href="firmware/">固件示例</a> ·
  <a href="downloads/MANIFEST.md">资料校验</a>
</p>

<p align="center">
  🛠️ <a href="https://github.com/HuaqiuOpenHardware/xinghongpai-nearlink-dev-board/issues/new/choose">提交问题</a>
  &nbsp;·&nbsp;
  🤝 <a href="CONTRIBUTING.md">参与贡献</a>
  &nbsp;·&nbsp;
  ⭐ <a href="https://github.com/HuaqiuOpenHardware/xinghongpai-nearlink-dev-board">收藏项目</a>
</p>

星鸿派是一款基于海思 **WS63V100 / Hi3863** 平台的开源开发板，支持 **星闪 NearLink（SLE）**、Wi-Fi 和 BLE，面向 OpenHarmony 学习、物联网原型、智能家电、环境监测与嵌入式教学。本仓库直接开放 KiCad 原理图与 PCB、BOM，以及 OpenHarmony / Hi3863 固件示例。

> 本仓库整理自华秋开源硬件社区公开项目。硬件许可证的具体 CERN-OHL 版本尚待项目方确认；复刻、修改或商用前请先阅读[许可证说明](#许可证说明)。

## 一眼看懂

| 项目 | 内容 |
| --- | --- |
| 主控平台 | HiSilicon WS63V100 / Hi3863 系列 |
| 无线连接 | NearLink SLE、Wi-Fi、BLE |
| 软件方向 | OpenHarmony / Hi3863 示例工程 |
| 板载资源 | 0.96 寸 OLED、6 个用户按键、复位按键、温湿度模块 |
| 硬件资产 | KiCad 工程、原理图、PCB、BOM |
| PCB 信息 | 约 96 mm × 70 mm，双层板（来自原项目页） |
| 适用人群 | 嵌入式开发者、创客、学生、教师与硬件研究者 |

## 开放资料

| 想找什么 | 仓库入口 | 当前状态 |
| --- | --- | --- |
| 原理图与 PCB 源文件 | [`hardware/kicad/`](hardware/kicad/) | 已提交，可直接查看与下载 |
| BOM 物料清单 | [`hardware/bom/`](hardware/bom/) | 已提交 XLSX |
| OpenHarmony / Hi3863 示例 | [`firmware/examples/`](firmware/examples/) | 已提交；依赖外部 SDK，不是独立工程 |
| 硬件与固件使用边界 | [`hardware/README.md`](hardware/README.md)、[`firmware/README.md`](firmware/README.md) | 已说明 |
| 原始资料来源与校验值 | [`downloads/MANIFEST.md`](downloads/MANIFEST.md) | 已记录 URL、大小和 SHA256 |
| 项目事实与来源 | [`PROJECT_FACTSHEET.md`](PROJECT_FACTSHEET.md) | 已整理 |
| 导入时的改动 | [`CHANGES_FROM_ORIGINAL.md`](CHANGES_FROM_ORIGINAL.md) | 已记录 |

原项目页提到 Gerber 文件，但首次导入使用的 PCB 下载包中没有独立 Gerber 制造文件。本仓库不把“页面提到”表述成“仓库已经提供”。

## 快速开始

### 查看或修改硬件

1. 打开 [`hardware/kicad/`](hardware/kicad/) 并下载 `.kicad_pro`、`.kicad_sch` 与 `.kicad_pcb` 文件。
2. 使用 KiCad 打开工程；复刻前同时核对原理图、PCB、[`BOM`](hardware/bom/) 和板卡实物版本。
3. 生成 Gerber、钻孔文件或贴片文件前，重新执行 ERC/DRC，并人工确认封装、替代料、电源与射频设计。

### 使用固件示例

1. 先阅读 [`firmware/README.md`](firmware/README.md)，确认示例并非可独立编译的完整 SDK。
2. 准备与示例匹配的 OpenHarmony / Hi3863（WS63）SDK 环境。
3. 从 GPIO、定时器、AHT20、OLED 等基础示例开始，再进入 Wi-Fi、TCP/UDP 与综合应用示例。
4. 提交问题时请提供 SDK / OpenHarmony 版本、示例目录、完整编译日志和板卡版本。

> 仓库尚未提供经过维护者复核的统一编译命令，因此这里不编造“一键编译”步骤。欢迎通过 Issue 或 Pull Request 补充可复现的环境说明。

## 固件示例方向

仓库中已有线程、定时器、互斥锁、信号量、消息队列、GPIO、AHT20、ADC、OLED、Wi-Fi、TCP/UDP，以及风扇、火焰检测、交通灯、继电器、温湿度等示例。具体文件以 [`firmware/examples/`](firmware/examples/) 为准。

推荐起点：

- [`11_aht20`](firmware/examples/11_aht20/)：AHT20 温湿度传感器
- [`13_adclight`](firmware/examples/13_adclight/)：ADC 光线采集
- [`14_easy_wifi`](firmware/examples/14_easy_wifi/)：Wi-Fi 连接与热点
- [`201_oled`](firmware/examples/201_oled/)：OLED 显示

## 仓库结构

```text
.
├── .github/                 # Issue 与 Pull Request 模板
├── assets/                 # 封面与实物图片
├── downloads/              # 原始下载地址、文件大小与 SHA256
├── firmware/
│   └── examples/           # OpenHarmony / Hi3863 固件示例
├── hardware/
│   ├── bom/                # BOM 物料清单
│   └── kicad/              # KiCad 原理图与 PCB 工程
├── LICENSES/               # 混合内容的许可证说明
├── CONTRIBUTING.md
├── PROJECT_FACTSHEET.md
├── README.md
└── README_EN.md
```

## 许可证说明

这个仓库包含硬件、固件和第三方资料，不能用一个未经确认的许可证覆盖全部内容：

- 原项目页的许可证字段显示 **CERN Open Hardware License**，但没有注明 CERN-OHL-S、W 或 P 等具体版本。
- 原项目页正文另有 Apache 2.0 与商用表述，两处口径并不完全一致。
- 多个固件文件保留了 HiHope Open Source Organization、HiSilicon 等来源的 Apache-2.0 版权头。
- 芯片文档、SDK、工具和原始压缩包可能适用各自的上游条款。

复刻、再分发、批量制造或商业化前，请阅读 [`LICENSE`](LICENSE) 与 [`LICENSES/README.md`](LICENSES/README.md)，并向项目方确认硬件许可证的准确版本。不要删除文件内已有的版权与许可证声明。

## 参与项目

- 硬件问题：使用 Hardware Issue 模板，注明板卡版本、测量结果、照片与复现步骤。
- 固件问题：使用 Firmware Issue 模板，注明 SDK / OpenHarmony 版本和完整日志。
- 提交修改：先阅读 [`CONTRIBUTING.md`](CONTRIBUTING.md)，并说明 BOM、硬件、固件和许可证影响。
- 安全问题：不要在公开 Issue 中提交 Wi-Fi 密码、密钥或生产设备凭据，详见 [`SECURITY.md`](SECURITY.md)。

## 来源与搜索别名

原始项目：华秋开源硬件社区「[星鸿派-星闪开发板](https://p.eda.cn/d-1328625634846441472)」。

相关名称：星闪、NearLink、SLE、SparkLink、WS63、WS63V100、Hi3863、HiSilicon、OpenHarmony、open-source hardware、development board、schematic、PCB、BOM、KiCad。

---

## 获取帮助与加入交流

如果你正在查找星闪开发资料、搭建 OpenHarmony / Hi3863 环境、复刻硬件，或希望交流项目使用与二次开发，可以添加 **华秋开源硬件小助手**。

添加后可获取：

- 星鸿派项目资料导航与更新提醒
- 开源硬件交流群入群方式
- 社区活动、试用与共创信息
- Issue 提交和项目反馈指引

<p align="center"><strong>微信扫码添加小助手</strong></p>

<p align="center">添加时建议备注“星鸿派”，方便更快对接相关资料与交流群。</p>

## KiCad design hardware/kicad/HXTX_XS_WEAR_底板_4.0_v125_2026-01-09-12-46.kicad_pcb

File hardware/README.md:

# Hardware | 硬件设计

This directory contains the KiCad hardware source files and BOM for the Xinghongpai NearLink development board.

本目录保存星鸿派 WS63V100 / Hi3863 星闪开发板的 KiCad 原理图、PCB 与 BOM。制造或修改前请同时核对原理图、PCB、BOM 和实际板卡版本。

## Files

- `kicad/*.kicad_pro`: KiCad project.
- `kicad/*.kicad_sch`: Schematic source.
- `kicad/*.kicad_pcb`: PCB layout source.
- `bom/BOM_Board1_Schematic1_2026-01-09.xlsx`: Bill of materials.

## Notes

The p.eda.cn page describes a 96 mm x 70 mm two-layer PCB. Gerber files were mentioned on the page but were not present as separate files in the downloaded PCB zip used for this import.

Before fabrication:

1. Open the complete project rather than a single schematic or PCB file.
2. Re-run ERC/DRC with the KiCad version used for your modification.
3. Verify footprints, alternative parts, connector orientation, power rails and RF-related layout against the intended board revision.
4. Generate fresh Gerber, drill, position and BOM outputs from the reviewed source. Do not treat generated files from an unknown revision as authoritative.
5. Record material substitutions and board changes in the Pull Request.

The presence of source files is not evidence that a modified board has been fabricated or electrically validated. Clearly label unverified derivatives.

Parts:
A: TS665WS 250gf; SW-SMD_L6.0-W6.0-LS6.6; Manufacturer Part TS665WS 250gf; LCSC Part Name 无声按键开关 6*6*5mm 250G
B: TS665WS 250gf; SW-SMD_L6.0-W6.0-LS6.6; Manufacturer Part TS665WS 250gf; LCSC Part Name 无声按键开关 6*6*5mm 250G
C: TS665WS 250gf; SW-SMD_L6.0-W6.0-LS6.6; Manufacturer Part TS665WS 250gf; LCSC Part Name 无声按键开关 6*6*5mm 250G
C1, C4, C5, C8, C11, C14, C20: 100nF; C0603; Manufacturer Part CL10B104KB8NNNC; LCSC Part Name 100nF ±10% 50V
C2, C3, C7, C10: 22uF; C0603; Manufacturer Part CL21A226MAQNNNE; LCSC Part Name 22uF ±20% 25V
C6, C21: 4.7uF; C0603; Manufacturer Part CL10A475KO8NNNC; LCSC Part Name 4.7uF ±10% 16V
CN6: WAFER-XH254WZ-2AM; CONN-TH_2P-P2.50_WAFER-XH254WZ-2A; Manufacturer Part WAFER-XH254WZ-2AM; LCSC Part Name 1x2P 间距:2.54mm 弯插 系列:XH
D: TS665WS 250gf; SW-SMD_L6.0-W6.0-LS6.6; Manufacturer Part TS665WS 250gf; LCSC Part Name 无声按键开关 6*6*5mm 250G
D1: NCD0805R1; LED-0805; Manufacturer Part NCD0805R1; LCSC Part Name NCD0805R1
D2: SMF12CA; SOD-123FL_L3.0-W1.8-LS3.7-BI; Manufacturer Part SMF12CA; LCSC Part Name SMF12CA
E: TS665WS 250gf; SW-SMD_L6.0-W6.0-LS6.6; Manufacturer Part TS665WS 250gf; LCSC Part Name 无声按键开关 6*6*5mm 250G
H: TS665WS 250gf; SW-SMD_L6.0-W6.0-LS6.6; Manufacturer Part TS665WS 250gf; LCSC Part Name 无声按键开关 6*6*5mm 250G
H1, H2, H3, H4: TP; HOLE-3.2X5.5
J9, J10: KH-2.54FH-1X12P-H8.5; HDR-TH_12P-P2.54-V-F; Manufacturer Part KH-2.54FH-1X12P-H8.5; LCSC Part Name 间距:2.54mm 1x12P 直插
J11, J12: X6511WV-12H-C60D30; HDR-TH_12P-P2.54-V-M; Manufacturer Part X6511WV-12H-C60D30; LCSC Part Name 1x12P 间距:2.54mm 方针
OLED1: HS96L03W2C03; 0.96OLED_4P; Manufacturer Part HS96L03W2C03; LCSC Part Name 0.96寸OLED显示屏窄白光IIC
R1, R2: 0Ω; R0603; Manufacturer Part 0603WAF0000T5E; LCSC Part Name 0Ω ±1% 100mW 厚膜电阻
R3, R4: 5.1kΩ; R0603; Manufacturer Part 0603WAF5101T5E; LCSC Part Name 5.1kΩ ±1% 100mW 厚膜电阻
R5: 470Ω; R0603; Manufacturer Part 0603WAF4700T5E; LCSC Part Name 470Ω ±1% 100mW 厚膜电阻
R6, R7: 10kΩ; R0603; Manufacturer Part 0603WAF1002T5E; LCSC Part Name 厚膜电阻 10kΩ ±1% 100mW
R11: 1kΩ; R0603; Manufacturer Part 0603WAF1001T5E; LCSC Part Name 1kΩ ±1% 100mW 厚膜电阻
R12, R22: 100kΩ; R0603; Manufacturer Part 0603WAF1003T5E; LCSC Part Name 100kΩ ±1% 100mW 厚膜电阻
R13, R14, R15, R16, R18, R21, R23: 300Ω; R0603; Manufacturer Part 0603WAF3000T5E; LCSC Part Name 300Ω ±1% 100mW 厚膜电阻
R19, R20: 4.7kΩ; R0603; Manufacturer Part 0603WAF4701T5E; LCSC Part Name 4.7kΩ ±1% 100mW 厚膜电阻
RESRT: OS4D502110; SW-SMD_L6.0-W6.0-P6.00-LS6.8; Manufacturer Part OS4D502110; LCSC Part Name 轻触开关6*6*5 翘两脚贴片硅胶柄无声开关 260gf
U1: AHT20; DFN-6_L3.0-W3.0-P1.00-BL; Manufacturer Part AHT20; LCSC Part Name AHT20
U2: CH340N; SOP-8; Manufacturer Part CH340N; LCSC Part Name USB2.0芯片CH340
U3: AMS1117-3.3; SOT-223-3_L6.5-W3.4-P2.30-LS7.0-BR; Manufacturer Part AMS1117-3.3; LCSC Part Name 输出3.3V 1A
U6: F63VA01
Z1: HX TYPE-C 16PIN; USB-C-SMD_TYPE-C16PIN; Manufacturer Part HX TYPE-C 16PIN; LCSC Part Name Type-C 母 卧贴
按键开关: PZ254V-11-03P; HDR-TH_3P-P2.54-V-M; Manufacturer Part PZ254V-11-03P; LCSC Part Name 1x3P 间距:2.54mm 方针 直插

Connections:
3V3: A.4, C3.2, C4.2, C5.2, C7.2, C8.2, C21.2, J9.11, J10.11, J11.11, J12.11, OLED1.2 (VCC), R5.2, R6.2, R7.2, R13.2, R19.2, R20.2, R22.2, R23.2, U2.5 (VCC), U2.8 (V3), U3.2 (VOUT), U3.4 (VOUT), U6.29 (VCC)
$1N2431: A.1, B.1, C.1, D.1, E.1, H.1, R11.1, R12.2
$1N2435: D1.1 (A), R23.1
$1N2450: D.4, R15.1, R16.2
$1N2451: C.4, R13.1, R14.2
$1N2465: C6.2, R5.1, U1.2 (VDD)
$1N2468: H.4, R18.1, R21.2
$1N2469: E.4, R16.1, R18.2
$1N2472: B.4, R14.1, R15.2
$1N2495: R2.1, Z1.A7 (DN1), Z1.B7 (DN2)
$1N2496: R1.1, Z1.A6 (DP1), Z1.B6 (DP2)
$1N10163: J10.9, J12.9, U6.14 (GPIO_9)
CC1: R3.2, Z1.A5 (CC1)
CC2: R4.2, Z1.B5 (CC2)
D+: R1.2, U2.1 (UD+)
D-: R2.2, U2.2 (UD-)
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C10.1, C11.1, C14.1, C20.1, C21.1, CN6.1, D1.2 (K), D2.1 (A), H1.1, H2.1, H3.1, H4.1, J9.12, J10.10, J11.1, J11.12, J12.10, OLED1.1 (GND), R3.1, R4.1, R12.1, R21.1, RESRT.1, U1.5 (GND), U2.3 (GND), U3.1 (GND), U6.1 (GND), U6.3 (GND), U6.11 (GND), U6.20 (GND), U6.26 (GND), U6.28 (GND), U6.30 (GND), Z1.1 (SHELL0), Z1.2 (SHELL1), Z1.3 (SHELL2), Z1.4 (SHELL3), Z1.A1B12 (GND), Z1.B1A12 (GND)
IO0: J9.2, J11.2, U6.4 (GPIO_0)
IO1: J9.3, J11.3, U6.5 (GPIO_1)
IO2: J9.5, J11.5, U6.6 (GPIO_2)
IO4: J9.6, J11.6, U6.8 (GPIO_4)
IO5: J9.7, J11.7, U6.9 (GPIO_5)
IO6: J9.8, J11.8, U6.10 (GPIO_6)
IO7: J9.9, J11.9, 按键开关.1
IO8: J9.10, J11.10, U6.13 (GPIO_8)
IO10: J10.8, J12.8, U6.15 (GPIO_10)
IO11: J10.7, J12.7, U6.16 (GPIO_11)
IO12: J10.6, J12.6, U6.17 (GPIO_12)
IO13: J10.5, J12.5, U6.18 (GPIO_13)
IO14: J10.3, J12.3, U6.19 (GPIO_14)
KEY_ADC: C14.2, R11.2, 按键开关.3
KEY_ADC_M: U6.12 (GPIO_7), 按键开关.2
RESET: C20.2, J9.4, J11.4, R22.1, RESRT.2, U6.27 (RST)
RXD: U2.6 (TXD), U6.24 (RXD0)
SCL: J10.1, J12.1, OLED1.3 (SCL), R7.1, R20.1, U1.3 (SCL), U6.22 (RXD1)
SDA: J10.2, J12.2, OLED1.4 (SDA), R6.1, R19.1, U1.4 (SDA), U6.21 (TXD1)
TXD: U2.7 (RXD), U6.23 (TXD0)
USB_5V: C1.2, C2.2, C10.2, C11.2, CN6.2, D2.2 (K), J10.12, J12.12, U3.3 (VIN), Z1.A4B9 (VBUS), Z1.B4A9 (VBUS)

Notes on the sheet:
0.96寸 OLED
按键开关

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
Board: 2 copper layers, 96.0 x 70.0 mm, 57 parts (0 on the bottom side), 39 nets.
